# Keil uVision project final.uvproj, settings and files
target final (ARM-ADS)
  device: LPC1768 NXP
  cpu: IRAM(0x10000000-0x10007FFF) IRAM2(0x2007C000-0x20083FFF) IROM(0-0x7FFFF) CLOCK(12000000) CPUTYPE("Cortex-M3")
  output: final
  AfterMake: fromelf --bin --output=@L.bin !L
  c flags: Optim=1 uC99=1
  c define: TOOLCHAIN_ARM, MBED_BUILD_TIMESTAMP=1463031398, ARM_MATH_CM3, TARGET_LIKE_CORTEX_M3, TARGET_CORTEX_M, TARGET_LIKE_MBED, TARGET_LPC176X, TARGET_NXP, TARGET_LPC1768, __MBED__=1, __CORTEX_M3, TARGET_M3, TARGET_MBED_LPC1768, TOOLCHAIN_ARM_STD, __ASSERT_MSG
  c misc: --gnu --no_rtti --restrict --apcs=interwork -c -O3 -I"C:/Program Files/ARM/armcc_4.1_791/include" --split_sections --multibyte_chars --brief_diagnostics -D__ASSERT_MSG --no_depend_system_headers --md --cpu=Cortex-M3 -Otime --gnu --brief_diagnostics --cpu=Cortex-M3 --apcs=interwork
  c include: .; Servo; Adafruit-PWM-Servo-Driver; NeoStrip; PinDetect; PololuLedStrip; mbed; mbed/TARGET_LPC1768; mbed/TARGET_LPC1768/TARGET_NXP; mbed/TARGET_LPC1768/TARGET_NXP/TARGET_LPC176X; mbed/TARGET_LPC1768/TARGET_NXP/TARGET_LPC176X/TARGET_MBED_LPC1768; mbed/TARGET_LPC1768/TOOLCHAIN_ARM_STD
  asm define: as above
  asm misc: --brief_diagnostics -I"C:/Program Files/ARM/armcc_4.1_791/include" --cpu=Cortex-M3 --apcs=interwork
  memory RVCT4: ROM 0x0 size 0x20000
  memory RVCT9: RAM 0x20000000 size 0x3000
  scatter file: mbed/TARGET_LPC1768/TOOLCHAIN_ARM_STD/LPC1768.sct
  group Include Files
    Adafruit-PWM-Servo-Driver/: Adafruit_PWMServoDriver.h
    mbed/: AnalogIn.h analogin_api.h AnalogOut.h analogout_api.h buffer.h BusIn.h BusInOut.h BusOut.h CallChain.h CAN.h can_api.h can_helper.h CircularBuffer.h CThunk.h DigitalIn.h DigitalInOut.h DigitalOut.h DirHandle.h dma_api.h Ethernet.h ethernet_api.h FileBase.h FileHandle.h FileLike.h FilePath.h FileSystemLike.h FunctionPointer.h gpio_api.h gpio_irq_api.h I2C.h i2c_api.h I2CSlave.h InterruptIn.h InterruptManager.h LocalFileSystem.h LowPowerTicker.h LowPowerTimeout.h LowPowerTimer.h lp_ticker_api.h mbed.h mbed_assert.h mbed_debug.h mbed_error.h mbed_interface.h pinmap.h platform.h port_api.h PortIn.h PortInOut.h PortOut.h PwmOut.h pwmout_api.h RawSerial.h rtc_api.h rtc_time.h semihost_api.h Serial.h serial_api.h SerialBase.h sleep_api.h SPI.h spi_api.h SPISlave.h Stream.h Ticker.h ticker_api.h Timeout.h Timer.h TimerEvent.h toolchain.h Transaction.h us_ticker_api.h wait_api.h
    mbed/TARGET_LPC1768/: arm_common_tables.h arm_const_structs.h arm_math.h cmsis.h cmsis_nvic.h core_ca9.h core_ca_mmu.h core_caFunc.h core_caInstr.h core_cm0.h core_cm0plus.h core_cm3.h core_cm4.h core_cm4_simd.h core_cm7.h core_cmFunc.h core_cmInstr.h core_cmSimd.h core_sc000.h core_sc300.h LPC17xx.h system_LPC17xx.h
    PinDetect/: ChangeLog.h example.h PinDetect.h
    mbed/TARGET_LPC1768/TARGET_NXP/TARGET_LPC176X/TARGET_MBED_LPC1768/: device.h PinNames.h reserved_pins.h
    mbed/TARGET_LPC1768/TARGET_NXP/TARGET_LPC176X/: gpio_object.h objects.h PeripheralNames.h PortNames.h
    NeoStrip/: NeoStrip.h
    PololuLedStrip/: PololuLedStrip.h
    Servo/: Servo.h
  group Source Files
    Adafruit-PWM-Servo-Driver/: Adafruit_PWMServoDriver.cpp
    mbed/TARGET_LPC1768/TOOLCHAIN_ARM_STD/: board.o cmsis_nvic.o mbed.ar retarget.o startup_LPC17xx.o sys.o system_LPC17xx.o
    PololuLedStrip/: led_strip_write_color.s PololuLedStrip.cpp
    ./: main.cpp
    NeoStrip/: NeoCore.s NeoStrip.cpp
    Servo/: Servo.cpp
